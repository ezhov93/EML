# Keil uVision project c_libs_prj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: c_libs_prj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group EML
    ./EML/: echar.c ecore.c einterrupts.c emath.c enew.c epio.c epio_private.c eprint.c ering_private.c eserial.c estartup.c estream.c estring.c etime.c etimer.c itoa.c main.c
software components: Device:Startup 1.5, Drivers:ADC 1.5, Drivers:BKP 1.5, Drivers:DAC 1.5, Drivers:LIB 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:SSP 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5
