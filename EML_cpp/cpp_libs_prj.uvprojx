# Keil uVision project cpp_libs_prj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cpp_libs_prj +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --cpp11
  c include: .\EML
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: test.cpp
  group EML
    ./EML/: ebits.h echar.cpp echar.h ecore.h emath.cpp emath.h enew.cpp enew.h epio.cpp epio.h etypes.h itoa.c itoa.h main.cpp epio_private.cpp epio_private.h estartup.cpp estartup.h ecore.cpp einterrupts.cpp einterrupts.h etime.cpp etime.h etimer.cpp etimer.h eprint.cpp eprint.h eserial.cpp eserial.h estream.cpp estream.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.5, Drivers:ADC 1.5, Drivers:DAC 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:TIMER 1.5
